# Keil uVision project Tinyg.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tinyg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --gnu
  c include: ..\src\STM32F4xx_StdPeriph_Driver\inc;..\src;..\src\tinyg\xio;..\src\Drivers;..\src\tinyg;..\src\tinyg\xmega
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group stm32
    ../src/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c startup_stm32f40xx.s
  group App
    ../src/: main.h main.c
    ../src/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_it.c
  group TinyG-XIO
    ../src/tinyg/xio/: xio_usart.c xio_usart.h
  group TinyG-C
    ../src/tinyg/: canonical_machine.c config.c config_app.c controller.c cycle_homing.c cycle_jogging.c cycle_probing.c encoder.c gcode_parser.c gpio.c hardware.c help.c json_parser.c kinematics.c persistence.c plan_arc.c plan_exec.c plan_line.c plan_zoid.c planner.c pwm.c report.c spindle.c stepper.c switch.c test.c text_parser.c util.c xio.c main.c system.c
  group RTT
    ../src/Drivers/RTT/: SEGGER_RTT.c SEGGER_RTT_Printf.c
  group Dev
    ../src/Drivers/: xyz_io.c xyz_io.h xuart.c xuart.h
  group TinyG-H
    ../src/tinyg/: canonical_machine.h config.h config_app.h controller.h encoder.h gcode_parser.h gpio.h hardware.h help.h json_parser.h kinematics.h persistence.h plan_arc.h plan_line.h planner.h pwm.h report.h settings.h spindle.h stepper.h switch.h system.h test.h text_parser.h tinyg.h util.h xio.h
